## conf/machine/include/fsl-default-settings.inc
```bitbake
# Freescale BSP default settings
OVERRIDES =. "fslbsp:"

IMAGE_CLASSES += "image_types_fsl"
```
